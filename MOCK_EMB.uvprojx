# Keil uVision project MOCK_EMB.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MOCK_EMB
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Users\Admin\AppData\Local\Arm\Packs\Keil\S32_SDK_DFP\1.5.0\platform\devices\S32K144\include;.\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: C:\Users\Admin\AppData\Local\Arm\Packs\Keil\S32_SDK_DFP\1.5.0\platform\devices\S32K144\linker\armc\S32K144_64_flash.sct
  group inc
    ./inc/: clock_and_modes.h GPIO_Config.h GPIO_Register.h LPIT_Config.h LPIT_Register.h LPSPI_Config.h LPSPI_Register.h LPUART_Register.h MAX7219.h PCC_Register.h PORT_Register.h SCG_Register.h SysTick.h UART_Config.h MY_LIBRARY.h FTFC.h
  group src
    ./src/: clock_and_modes.c GPIO_Config.c LPIT_Config.c LPSPI_Config.c main.c MAX7219.c UART_Config.c FTFC.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.0.0
